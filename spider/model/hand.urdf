Commit message: pen rotation

File: spider/model/hand.urdf (robot description, URDF)
Before this commit: robot rocketbox_male, 53 links, 52 joints
Links:
- link torso_x_link: geometry collision mesh filename=../spider/model/mesh/RootHand.obj; visual mesh filename=../spider/model/mesh/RootHand.obj
